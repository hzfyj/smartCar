# Keil uVision project MK66_HDU.uvprojx, settings and files
target MK66_HDU (ARM-ADS)
  device: MK66FX1M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MK66_HDU
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\SRC\FWLIB\inc;..\SRC\HARDWARE\inc;..\SRC\SMARTCAR\inc;..\SRC\STARTUP\CoreSupport;..\SRC\STARTUP\DeviceSupport;..\SRC\STARTUP\DeviceSupport\MDK-ARM;..\SRC\USER;..\SRC\HARDWARE\data;..\SRC\HARDWARE\data_sd;..\SRC\HARDWARE\data_send;..\SRC\HARDWARE\dmacnt;..\SRC\HARDWARE\menu;..\SRC\HARDWARE\pidcontrol;..\SRC\HARDWARE\process;..\SRC\HARDWARE\sonyccd;..\SRC\HARDWARE\Fuzzy;..\SRC\HARDWARE\IMU_IIC;..\SRC\HARDWARE\L3G4200D;..\SRC\HARDWARE\NewFuzzy
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group STARTUP
    ../SRC/STARTUP/DeviceSupport/: system_MK66.c
  group SMARTCAR
    ../SRC/SMARTCAR/src/: sd_storage.c key.c
  group USER
    ../SRC/USER/: main.c isr.c Readme.txt
    ../SRC/FWLIB/inc/: headfile.h
  group FWLIB
    ../SRC/FWLIB/src/: adc.c cmt.c common.c dac.c dma.c flash.c ftm.c gpio.c i2c.c lptmr.c misc.c systick.c pit.c rtc.c port.c sdhc.c spi.c uart.c wdog.c dmacnt.c dma_old.c
    ../SRC/FWLIB/inc/: port_cfg.h
  group HARDWARE
    ../SRC/HARDWARE/src/: SEEKFREE_MT9V032.c sd_yaoxin.c nrf2401.c oled.c
    ../SRC/STARTUP/DeviceSupport/MDK-ARM/: startup_MK66F18.s
    ../SRC/HARDWARE/data/: data.c
    ../SRC/HARDWARE/menu/: menu.c
    ../SRC/HARDWARE/pidcontrol/: pidcontrol.c
    ../SRC/HARDWARE/process/: process.c
    ../SRC/HARDWARE/sonyccd/: sonyccd.c
    ../SRC/HARDWARE/Fuzzy/: Fuzzy_control.c
    ../SRC/HARDWARE/IMU_IIC/: IMU_IIC.c
    ../SRC/HARDWARE/L3G4200D/: L3G4200D.c
    ../SRC/HARDWARE/NewFuzzy/: NewFuzzy1.c
